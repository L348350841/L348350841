# Keil uVision project 2021ROBOCON.uvprojx, settings and files
target PR (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: 2020ROBOCON
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__FPU_USED =1,ARM_MATH_CM4
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE\control;..\HARDWARE\pwm;..\HARDWARE\led;..\HARDWARE\timer;..\HARDWARE\can1;..\HARDWARE\bsp;..\HARDWARE\AllPara;..\HARDWARE\can;..\HARDWARE\NRF24L01;..\HARDWARE\LCD;..\HARDWARE\SPI;..\HARDWARE\LCD;..\HARDWARE\ReceiveData;..\HARDWARE\task;..\HARDWARE\relay;..\HARDWARE\ADS1115;..\HARDWARE\MCP4725;..\HARDWARE\IIC;..\HARDWARE\PID;..\HARDWARE\send;..\HARDWARE\arctan;..\HARDWARE\MUSART;..\HARDWARE\DRIVER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/bsp/: bsp.c
    ../HARDWARE/control/: control.c
    ../HARDWARE/can1/: can1.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/pwm/: pwm.c
    ../SYSTEM/sys/: sys.c
    ../HARDWARE/timer/: timer.c
    ../HARDWARE/AllPara/: AllPara.c
    ../HARDWARE/can/: can.c
    ../HARDWARE/NRF24L01/: 24l01.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/ReceiveData/: ReceiveData.c
    ../HARDWARE/task/: task.c
    ../HARDWARE/relay/: relay.c
    ../HARDWARE/ADS1115/: ADS1115.c
    ../HARDWARE/MCP4725/: MCP4725.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/PID/: pid.c
    ../HARDWARE/send/: send.c
    ../HARDWARE/arctan/: TaneTable.c
    ../HARDWARE/MUSART/: musart.c
    ../HARDWARE/DRIVER/: driver.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_tim.c stm32f4xx_fsmc.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_iwdg.c stm32f4xx_exti.c stm32f4xx_spi.c arm_cos_f32.c arm_sin_f32.c
